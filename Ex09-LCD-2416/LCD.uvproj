# Keil uVision project LCD.uvproj, settings and files
target LCD (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1 OneElfS=1
  c define: _LCD_LANDSCAPE
  c include: ..\BSP\include;..\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ../CMSIS/src/: system_LPC17xx.c startup_LPC17xx.s
  group User
    ./Source/User/: main.c
  group BSP
    ../BSP/source/: LCD.c BSP_Config.c game.c
  group Drivers
    ../Drivers/source/: timer.c joystick.c
